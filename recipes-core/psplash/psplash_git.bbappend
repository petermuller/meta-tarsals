DEPENDS += "gdk-pixbuf-native"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SPLASH_IMAGES += "file://rpi-tarsals.png;outsuffix=rpi-tarsals"
